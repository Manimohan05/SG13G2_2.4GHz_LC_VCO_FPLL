**************************************
* SPICE STIMULI FILE
* generated from
**************************************

Ven en 0 PWL 0n 0 70n 0 75n 1.8 172n 1.8 177n 0
Vrst rst 0 PWL 0n 1.8 50n 1.8 55n 0
Vsclk sclk 0 PWL 0n 0 74n 0 79n 1.8 84n 0 85n 0 90n
+1.8 95n 0 96n 0 101n 1.8 106n 0 107n 0 112n 1.8 117n 0
+118n 0 123n 1.8 128n 0 129n 0 134n 1.8 139n 0 140n 0 145n
+1.8 150n 0 151n 0 156n 1.8 161n 0 162n 0 167n 1.8 172n 0
Vsdata sdata 0 PWL 0n 0
